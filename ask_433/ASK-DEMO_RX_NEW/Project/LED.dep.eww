<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\ASK-DEMO_flashtool\Project\LED_rx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LED_rx.ewp</path>
    </project>
    <batchBuild />
</workspace>
