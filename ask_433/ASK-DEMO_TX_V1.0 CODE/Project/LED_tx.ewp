# IAR project LED_tx.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\My_Lib\delay; ..\User; ..\System; ..\My_Lib\LED; ..\My_Lib\USART; ..\My_Lib\EEPROM; ..\My_Lib\TIME; ..\My_Lib\KEY
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group My_Lib
    ../My_Lib/delay/: delay.c
    ../My_Lib/EEPROM/: eeprom.c
    ../User/: fm24.c
    ../My_Lib/KEY/: key.c
    ../My_Lib/LED/: led.c
    ../My_Lib/TIME/: time.c
    ../My_Lib/USART/: USART.c
  group User
    ../User/: ASK.C main.c
