<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\接收demo\软件工程文件\Project\LED.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LED_tx.ewp</path>
    </project>
    <batchBuild />
</workspace>
