<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\ASK-DEMO_RX_NEW\Project\LED_rx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\ASK-DEMO_TX_V1.0 CODE\Project\LED_tx.ewp</path>
    </project>
    <batchBuild />
</workspace>
