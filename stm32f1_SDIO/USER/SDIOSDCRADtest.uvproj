# Keil uVision project SDIOSDCRADtest.uvproj, settings and files
target SDIOSDCARDtest (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SDIOSDCRADtest +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\sdiosdcard;..\HARDWARE\tft;..\MALLOC;..\FatFs;..\FatFs\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/sdiosdcard/: sdio_sdcard.c
    ../HARDWARE/tft/: fontupd.c lcd.c lcd_drive.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FatFs
    ../FatFs/: diskio.c ff.c
    ../FatFs/option/: ccsbcs.c
